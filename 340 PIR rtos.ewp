# IAR project 340 PIR rtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; DEBUG
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; src; Display; MLX90640; CMSIS; SPL; system; FreeRTOS; FreeRTOS\src; FreeRTOS\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSYS
    CMSIS/: cmsis.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h cortexm3_macro.h cortexm3_macro.s
  group Display
    Display/: lcd.c
  group Display/inc
    Display/: Agency_18.c Agency_29.c Arial_18.c Arial_29.c Battery_18.c Courier_18.c Courier_29.c lcd.h lcd_fonts.h lcd_types.h
  group Doc
    ../Doc/: 339_RF_remote.PDF PM0056 CortexM3 Programming.pdf RM0008 Reference manual.pdf
  group FreeRTOS
    FreeRTOS/src/: croutine.c event_groups.c list.c port.c portasm.s queue.c stream_buffer.c tasks.c timers.c
    FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/inc
    FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group MLX90640
    MLX90640/: MLX90640_API.cpp MLX90640_I2C_Driver.cpp
  group MLX90640/inc
    MLX90640/: MLX90640_API.h MLX90640_I2C_Driver.h
  group SPL
    SPL/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SPL/inc
    SPL/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group src
    src/: adc.c display.c encoder.c i2c.c init.c main.c menu.c palettes.c power_control.c
  group src/inc
    src/: adc.h display.h encoder.h global.h i2c.h init.h menu.h palettes.h power_control.h timer.h
  group System files
    system/: stm32_assert.h stm32f103xb_it.c system_stm32f10x.c
